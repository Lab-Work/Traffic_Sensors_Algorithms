# Keil uVision project test.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: factory2_2 +hex
  c define: USE_STDPERIPH_DRIVER, USE_USB_OTG_FS,ARM_MATH_CM4
  c include: ..\src;..\..\Libraries\CMSIS\ST\STM32F4xx\Include;..\..\Libraries\CMSIS\Include;..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\Libraries\STM32_USB_Device_Library\Core\inc;..\..\Libraries\STM32_USB_Device_Library\Class\hid\inc;..\..\Libraries\STM32_USB_OTG_Driver\inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Source Group 1
    ./: startup_stm32f4xx.s system_stm32f4xx.c maincpp01.cpp
  group testboardexample
    ../src/: btest_allsensors_v3.cpp
  group mytest_cpp
    ../src/: stm32f4xx_it.c sdio_sd.c WaspXBeeCore.cpp WaspEEPROM.cpp WaspFLASH.cpp WaspPWR.cpp WaspRTC.cpp WaspSD.cpp WaspSensor.cpp WaspUtils.cpp WaspXBee802.cpp WaspXBee.cpp test_usb.c matrix.c mysdfat.c dingke_timer.c dingke_uart.c dingke_smbus.c dingke_i2c.c dingke_spi.c dingke_pwr.c dingke_exti.c dingke_delay.c dingke_retarget.c dingke_sysclkchange.c test_xbeeonnlyforzhp.cpp dingke_wdg.c
    ../../Libraries/STM32F4xx_StdPeriph_Driver/inc/: stm32f4xx_wwdg.h
    ../../Libraries/STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_wwdg.c
  group libstm32f4
    ../../Libraries/STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_rcc.c stm32f4xx_gpio.c stm32f4xx_usart.c misc.c stm32f4xx_tim.c stm32f4xx_spi.c stm32f4xx_iwdg.c stm32f4xx_sdio.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_pwr.c stm32f4xx_syscfg.c
  group UsbDeviceLib
    ../../Libraries/STM32_USB_Device_Library/Core/src/: usbd_core.c usbd_ioreq.c usbd_req.c
    ../../Libraries/STM32_USB_Device_Library/Class/hid/src/: usbd_hid_core.c
  group UsbOTGDriver
    ../../Libraries/STM32_USB_OTG_Driver/src/: usb_dcd_int.c usb_core.c usb_dcd.c
  group UsbHid
    ../src/: usb_bsp.c usbd_desc.c usbd_usr.c
  group fat
    ../src/: ff.c diskio.c
  group DSP_Lib
    ../../Libraries/CMSIS/Lib/ARM/: arm_cortexM4lf_math.lib
